# Keil uVision project Tracker.uvprojx, settings and files
target V_1.1 (6150000::V6.15::ARMCLANG)
  device: STM32L151C8Tx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tracker +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Tracker;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source
    ../SOURCE/src/: main.c sysInit.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
